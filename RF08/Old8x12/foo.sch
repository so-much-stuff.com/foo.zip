# EAGLE board foo (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
OE\  (via drill 0.61) (continued)
  Top 0.203: v108.58,19.65 107.95,20.28 107.95,48.22 106.68,49.49 IC9.1 106.68,52.03 105.41,53.3 105.41,54.57 | v104.14,75.53 104.77,74.89 104.77,71.72 105.41,71.08 105.41,54.57 | 105.41,54.57 108.58,57.75 IC9.19
  Bottom 0.203: v108.58,19.65 110.48,17.74 132.08,17.74 133.98,19.65 IC3.6 | IC17.20 85.09,48.22 86.36,49.49 106.68,49.49 IC9.1 | v104.14,75.53 106.04,75.53 IC8.1
PWRCLR  (via drill 0.61)
  Top 0.203: v31.75,20.92 31.75,27.9 33.02,29.17 IC20.8 | v71.75,24.09 71.75,39.97 73.02,41.24 v73.02,48.22 | v54.6,53.3 54.6,65.37 55.24,66 55.24,77.43 54.6,78.07 54.6,79.34 53.34,80.61 SV1.3 | v114.3,93.94 114.3,90.13 IC25.4 | v125.09,94.58 131.44,100.93 154.3,100.93 154.3,96.48 158.75,92.04 158.75,69.81 159.38,69.18 159.38,53.94 160.65,52.67 160.65,50.76 v160.02,50.13 | v120.01,28.54 v120.01,41.24 | v88.26,23.46 87.62,22.82 v87.62,19.01
  Bottom 0.203: v31.75,20.92 32.38,20.28 42.54,20.28 43.81,19.01 69.21,19.01 | 69.21,19.01 71.75,21.55 v71.75,24.09 | v73.02,48.22 67.94,53.3 v54.6,53.3 | v114.3,93.94 114.93,94.58 v125.09,94.58 | v160.02,50.13 156.84,46.95 138.43,46.95 135.88,44.41 135.88,41.24 v120.01,41.24 | v120.01,28.54 116.84,25.36 106.04,25.36 104.14,23.46 v88.26,23.46 | 69.21,19.01 v87.62,19.01
SCL\  (via drill 0.61)
  Top 0.203: 26.03,17.74 26.03,20.92 26.67,21.55 26.67,27.9 27.94,29.17 IC20.10 27.94,31.71 29.21,32.98 v29.21,38.7 | 26.03,17.74 26.03,17.11 27.3,15.84 IC7.13 | v25.39,17.74 26.03,17.74 | IC18.1 49.52,40.6 52.06,43.14 52.06,45.68 IC18.13 | v45.71,99.02 44.45,97.75 44.45,74.26 45.71,72.99 45.08,72.35 45.08,43.14 45.71,42.51 v45.71,39.97
  Bottom 0.203: v25.39,17.74 21.59,17.74 IC7.1 | v45.71,99.02 64.13,99.02 65.4,100.29 66.04,100.29 66.67,99.66 67.31,99.66 67.94,99.02 106.68,99.02 108.58,97.12 IC25.13 | v45.71,39.97 48.89,39.97 IC18.1 49.52,40.6 31.11,40.6 v29.21,38.7
TRC  (via drill 0.61)
  Top 0.203: 58.41,36.79 58.41,8.85 57.14,7.58 IC5.5 | 58.41,36.79 59.68,38.06 IC18.5 | v104.14,24.73 104.14,21.55 IC21.6 | v76.2,26.63 76.83,27.27 76.83,41.87 76.2,42.51 v76.2,58.38 | v57.14,57.75 58.41,56.48 58.41,36.79
  Bottom 0.203: v104.14,24.73 102.87,26 83.18,26 82.55,26.63 v76.2,26.63 | v76.2,58.38 59.68,58.38 58.41,57.11 57.78,57.11 v57.14,57.75
V+  (via drill 0.61)
  Top 0.203: SV2.39 12.69,72.99 12.69,71.72 SV2.37 12.69,70.45 12.69,69.18 SV2.35 12.69,67.91 13.96,66.64 13.96,65.37 12.69,64.1 SV2.31 12.69,62.83 13.96,61.56 13.96,39.97 13.33,39.33 11.42,39.33 v11.42,7.58 | v45.71,37.43 45.71,25.36 44.45,24.09 IC2.2 44.45,21.55 44.45,3.14 35.55,3.14 34.92,3.77 26.67,3.77 v25.39,5.04 | IC22.15 154.3,50.13 154.3,48.86 IC22.14 155.57,47.59 156.84,46.32 v156.84,11.39 | v151.76,53.94 151.12,54.57 151.12,68.54 149.86,69.81 149.86,70.45 R2.1 | IC25.2 109.22,90.13 111.76,92.67 111.76,95.21 IC25.12 | IC27.2 136.52,79.34 136.52,80.61 IC27.1 | v125.73,81.88 125.73,93.31 120.01,93.31 117.47,95.85 IC25.10 | IC27.10 145.41,71.72 146.68,72.99 146.68,76.8 145.41,78.07 IC27.13 | IC15.10 46.35,95.85 47.62,95.85 IC15.9 48.25,95.21 50.79,92.67 v50.79,85.69 | v58.41,85.05 v58.41,58.38 58.41,57.11 59.05,56.48 59.05,47.59 IC18.10 | v78.1,59.02 78.1,52.03 80.01,50.13 80.01,42.51 78.73,41.24 78.73,40.6 80.01,39.33 80.01,29.17 78.73,27.9 78.73,19.01 79.37,18.38 79.37,12.03 80.64,10.76 IC16.9 81.91,9.49 81.91,1.87 98.42,1.87 102.87,6.31 103.5,5.68 v105.41,5.68 | v53.34,43.14 53.34,41.87 52.06,40.6 IC18.2
  Bottom 0.203: 53.97,37.43 52.7,38.7 IC18.2 | 53.97,37.43 55.24,37.43 56.51,38.7 IC18.4 | v45.71,37.43 53.97,37.43 | v11.42,7.58 12.69,6.31 22.22,6.31 23.49,5.04 v25.39,5.04 | IC27.10 146.05,71.08 149.22,71.08 R2.1 | v151.76,53.94 154.3,51.4 IC22.15 | v125.73,81.88 126.36,81.24 134.62,81.24 | 134.62,81.24 135.88,81.24 IC27.1 | IC27.13 143.5,78.7 138.43,78.7 IC27.2 | 134.62,81.24 129.53,86.32 111.76,86.32 109.85,88.23 IC25.2 | IC16.9 80.01,10.12 76.2,10.12 74.93,11.39 68.58,11.39 67.31,12.66 66.67,12.66 R1.1 | 56.51,48.86 55.24,47.59 IC18.12 | 56.51,48.86 57.78,48.86 59.05,47.59 IC18.10 | v50.79,85.69 57.78,85.69 v58.41,85.05 | v78.1,59.02 77.47,59.65 64.13,59.65 63.49,59.02 59.05,59.02 v58.41,58.38 | v156.84,11.39 145.41,11.39 144.14,10.12 114.93,10.12 110.48,5.68 v105.41,5.68 | v53.34,43.14 49.52,43.14 48.25,44.41 48.25,48.86 56.51,48.86
VCC  (via drill 0.61)
  Top 0.508: 30.48,99.02 30.48,97.75 IC15.16 | 30.48,99.02 30.48,100.29 50.79,100.29 53.34,97.75 IC1.20 | v16.51,20.28 16.51,27.9 17.78,29.17 IC20.14 17.78,31.71 v17.78,43.14 | v49.52,52.67 49.52,48.22 IC18.14 | 21.59,53.3 21.59,45.68 22.86,44.41 IC14.16 | 21.59,53.3 22.86,54.57 IC13.16 | 21.59,53.3 21.59,63.46 22.86,64.73 22.86,68.54 IC12.16 22.86,71.08 22.86,76.8 24.12,78.07 24.12,99.02 30.48,99.02 | IC4.16 121.92,41.87 121.28,41.24 121.28,37.43 120.65,36.79 120.65,30.44 121.92,29.17 IC3.14 121.92,26.63 120.65,25.36 120.65,17.74 121.92,16.47 IC10.14 121.28,14.57 v119.38,12.66 | v114.3,43.14 114.3,38.7 C6.1 | v81.28,40.6 81.28,28.54 IC16.16 | R1.2 65.4,17.74 64.77,17.74 IC5.14 62.86,18.38 62.86,19.65 v62.22,20.28 | v87.62,7.58 91.44,11.39 91.44,13.93 IC28.14 91.44,16.47 90.17,17.74 90.17,25.36 91.44,26.63 IC21.14 | IC2.20 41.9,29.17 43.17,27.9 v43.17,20.92 v43.17,12.66 | IC9.20 106.68,59.65 107.95,60.92 107.95,69.81 107.31,70.45 IC6.20 106.68,72.35 105.41,73.62 105.41,78.07 106.68,79.34 106.68,82.51 IC8.20 106.68,85.05 105.41,86.32 105.41,96.48 | 105.41,96.48 100.33,96.48 IC17.40 | 105.41,96.48 106.04,96.48 IC25.14 | SV4.8 157.47,74.26 156.21,75.53 156.21,76.8 157.47,78.07 SV4.4 157.47,79.34 157.47,80.61 SV4.2 | IC27.14 145.41,81.88 148.59,85.05 148.59,92.04 149.86,93.31 C10.1 | v132.08,77.43 132.08,71.72 C9.1 | 140.97,14.57 141.6,15.2 v141.6,26.63 | 140.97,14.57 139.69,13.3 C7.1 | v135.88,13.3 135.88,6.31 136.52,5.68 140.97,5.68 140.97,14.57 | v33.02,13.93 29.21,17.74 IC7.14
  Bottom 0.508: IC11.16 8.25,95.85 10.15,93.94 27.94,93.94 29.84,95.85 IC15.16 | 16.51,19.65 8.25,19.65 +5V.MP | 16.51,19.65 26.03,19.65 27.3,18.38 IC7.14 | 16.51,19.65 v16.51,20.28 | v49.52,52.67 48.89,53.3 43.81,53.3 C4.1 42.54,53.3 25.39,53.3 23.49,55.21 IC13.16 | v17.78,43.14 22.22,43.14 IC14.16 | v114.3,43.14 121.28,43.14 IC4.16 | IC21.14 90.8,27.9 82.55,27.9 IC16.16 | v81.28,40.6 88.26,40.6 IC19.20 | IC2.20 41.27,29.81 39.36,27.9 36.19,27.9 C1.1 | v87.62,7.58 86.99,8.22 80.01,8.22 79.37,7.58 C2.1 | R1.2 66.67,17.74 67.31,17.11 71.75,17.11 72.39,16.47 91.44,16.47 IC28.14 91.44,13.93 91.44,12.66 108.58,12.66 C5.1 109.85,12.66 v119.38,12.66 | v43.17,20.92 43.81,20.28 v62.22,20.28 | 90.17,96.48 91.44,97.75 93.98,97.75 95.25,96.48 97.79,96.48 IC17.40 | 90.17,96.48 88.9,95.21 82.55,95.21 81.28,93.94 79.37,93.94 C3.1 | R5.1 159.38,81.24 158.11,81.24 SV4.2 | C10.1 149.22,93.94 132.08,93.94 130.17,95.85 IC26.14 129.53,95.21 127.63,93.31 125.09,93.31 122.55,90.77 104.14,90.77 102.23,92.67 97.15,92.67 97.15,93.94 96.52,94.58 92.07,94.58 90.17,96.48 | v132.08,77.43 134.62,79.97 142.24,79.97 143.5,81.24 IC27.14 146.05,81.24 146.68,81.24 153.03,74.89 155.57,74.89 156.84,73.62 SV4.8 157.47,72.99 158.75,71.72 158.75,67.27 156.84,67.27 156.21,66.64 156.21,64.73 158.11,64.73 160.65,62.19 160.65,51.4 | 156.21,29.17 161.28,34.25 161.28,41.87 | 156.21,29.17 155.57,28.54 IC24.16 | 161.28,41.87 161.28,51.4 160.65,51.4 | 160.65,51.4 158.11,51.4 156.21,53.3 IC22.16 | v141.6,26.63 144.14,29.17 156.21,29.17 | 161.28,41.87 144.14,41.87 142.87,40.6 C8.1 | v135.88,13.3 123.82,13.3 122.55,14.57 IC10.14
  Bottom 0.508: v33.02,13.93 34.92,12.03 42.54,12.03 v43.17,12.66
WE\  (via drill 0.61)
  Top 0.203: v149.86,68.54 149.86,64.1 R2.2 | v106.68,68.54 106.68,64.73 IC6.1 | v44.45,34.25 44.45,31.71 IC2.19 | v48.25,34.25 47.62,34.89 47.62,44.41 48.25,45.05 48.25,56.48 50.16,58.38 50.16,67.91 v49.52,68.54 | v71.75,69.18 73.02,70.45 v73.02,82.51 | v76.2,82.51 v76.2,85.05 | v96.52,86.32 97.15,86.96 97.15,92.04 98.42,93.31 IC17.39 99.69,93.31 100.96,92.04 v100.96,72.35 | v107.95,78.07 107.95,73.62 109.22,72.35 IC6.19
  Bottom 0.203: 149.86,69.81 155.57,69.81 156.84,68.54 SV3.9 | 149.86,69.81 147.31,69.81 146.05,68.54 IC27.9 144.14,69.18 138.43,74.89 133.34,74.89 129.53,78.7 121.28,78.7 120.65,79.34 109.22,79.34 v107.95,78.07 | 149.86,69.81 v149.86,68.54 | v106.68,68.54 108.58,70.45 IC6.19 108.58,71.72 107.31,72.99 101.59,72.99 v100.96,72.35 | v44.45,34.25 v48.25,34.25 | v49.52,68.54 50.16,69.18 v71.75,69.18 | v73.02,82.51 v76.2,82.51 | v76.2,85.05 92.7,85.05 93.98,86.32 v96.52,86.32
WR\1  (via drill 0.61)
  Top 0.203: 132.71,57.11 132.71,50.76 129.53,47.59 v129.53,46.95 | 132.71,57.11 132.71,62.19 133.34,62.83 133.34,92.67 130.81,92.67 129.53,91.4 129.53,90.13 IC26.1 | 132.71,57.11 v133.34,57.11
  Bottom 0.203: v129.53,46.95 127.63,45.05 126.36,45.05 125.09,43.78 IC4.15 | v133.34,57.11 133.98,57.75 153.03,57.75 153.66,57.11 155.57,57.11 156.84,58.38 SV3.1
WR\2  (via drill 0.61)
  Top 0.203: v135.25,83.15 134.62,82.51 134.62,62.83 135.25,62.19 v135.25,59.65 v135.25,45.68
  Bottom 0.203: v135.25,83.15 133.34,85.05 132.08,85.05 132.08,87.59 IC26.2 | v135.25,59.65 136.52,58.38 154.3,58.38 SV3.2 | v135.25,45.68 129.53,45.68 127.63,43.78 IC4.14
WR\3  (via drill 0.61)
  Top 0.203: IC26.3 134.62,87.59 136.52,85.69 136.52,83.15 135.25,81.88 135.25,62.83 136.52,61.56 v136.52,59.65 136.52,50.13 135.88,49.49 135.88,46.32 136.52,45.68 136.52,45.05 135.88,44.41 135.88,41.87 135.25,41.24 129.53,41.24 129.53,41.87 IC4.13
  Bottom 0.203: v136.52,59.65 155.57,59.65 156.84,60.92 SV3.3
WR\4  (via drill 0.61)
  Top 0.203: v154.94,85.05 154.3,84.42 154.3,82.51 153.66,81.88 153.66,71.72 156.21,69.18 156.21,62.83 | 156.21,62.83 154.94,61.56 SV3.4 | v133.34,50.13 133.34,45.68 132.08,44.41 IC4.12 | v155.57,55.21 156.21,55.84 156.21,62.83
  Bottom 0.203: v154.94,85.05 151.12,85.05 151.12,86.96 150.49,87.59 149.22,87.59 148.59,86.96 139.06,86.96 137.79,88.23 IC26.4 | v133.34,50.13 138.43,55.21 v155.57,55.21
WR\5  (via drill 0.61)
  Top 0.203: v135.25,84.42 133.98,83.15 v133.98,62.19 133.98,57.75 134.62,57.11 134.62,46.32 133.98,45.68 133.98,43.78 IC4.11
  Bottom 0.203: v135.25,84.42 135.88,84.42 135.88,90.13 136.52,90.77 137.79,90.77 139.06,89.5 IC26.5 | v133.98,62.19 155.57,62.19 156.84,63.46 SV3.5
WR\6  (via drill 0.61)
  Top 0.203: IC26.6 142.24,87.59 v142.24,64.73 142.24,46.95 v140.97,45.68
  Bottom 0.203: v142.24,64.73 153.03,64.73 154.3,63.46 SV3.6 | v140.97,45.68 139.69,45.68 137.79,43.78 IC4.10
WR\7  (via drill 0.61)
  Top 0.203: v160.02,44.41 161.28,45.68 161.28,66 v160.65,66.64
  Bottom 0.203: IC26.11 137.79,95.85 139.06,94.58 148.59,94.58 149.22,95.21 155.57,95.21 161.28,89.5 161.28,66.64 v160.65,66.64 157.47,66.64 SV3.7 | v160.02,44.41 140.97,44.41 140.33,43.78 IC4.9
WR\8  (via drill 0.61)
  Top 0.203: v139.69,91.4 135.25,95.85 IC26.12 | v149.86,90.77 151.12,89.5 151.12,69.18 151.76,68.54 151.76,56.48 153.03,55.21 | 153.03,55.21 154.3,55.21 154.3,57.11 153.66,57.75 153.66,64.1 154.94,65.37 SV3.8 | v143.5,37.43 144.78,36.16 144.78,22.82 146.05,21.55 152.4,21.55 152.4,53.3 153.03,53.94 153.03,55.21
  Bottom 0.203: v139.69,91.4 140.33,90.77 v149.86,90.77 | v143.5,37.43 139.06,37.43 137.79,36.16 IC4.7
WRITELOCK_LED
  Bottom 0.203: SV4.1 154.3,81.24 152.4,83.15 R3.1

## Text on the board
tNames: DF32x4 Disk Emulator Rev. B (c)2003 CEMorris